# Repository Altairu/AltairMD_V6

## KiCad design AltairMD_V6/AltairMD_V6.kicad_pcb

Parts:
C1: UUD1V331MNL1GS330μf; CAPAE1030X1080N; Manufacturer_Part_Number UUD1V331MNL1GS; Mouser Part Number 647-UUD1V331MNL
C2, C5, C6, C7, C8, C16, C17, C18, C19: 220nf; C_1210_3225Metric
C3, C4, C9, C10, C14, C15, C20, C21: 100nf; C_0603_1608Metric
C11, C12, C13, C22: 1nf; C_0603_1608Metric
D1, D2, D3, D4, D5, D6: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1, IC2, IC3, IC4: IFX007TAUMA1; PG-TO263-7-1; Manufacturer_Part_Number IFX007TAUMA1; Mouser Part Number 726-IFX007TAUMA1
IC5: 74HC244D; SOIC127P1030X250-20N; Manufacturer_Part_Number 74HC244D; Mouser Part Number 757-74HC244D
J1, J2, J4: Conn_01x02; XT60PWM
J3: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Horizontal
R1, R2, R3, R4, R24, R25, R26, R27, R28, R29: 33KΩ; C_0603_1608Metric
R5, R6, R8, R9, R17, R22, R30, R31, R32, R33: 0.51k; C_0603_1608Metric
R10, R11, R12, R13, R18, R19, R20, R21: 10k; C_0603_1608Metric
R14, R15, R16, R23: 1k; C_0603_1608Metric

Connections:
+5V: C2.1, D2.2 (A), IC5.20 (VCC), J3.2
+24V: C1.1, C3.1, C4.1, C5.1, C6.1, C15.1, C16.1, C18.1, C20.1, D1.2 (A), IC1.7 (VS), IC2.7 (VS), IC3.7 (VS), IC4.7 (VS), J1.2
D1: IC5.1 (1~G), J3.3, R28.1
D2: IC5.19 (2~G), J3.4, R29.1
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C19.2, C20.2, C21.2, C22.2, IC1.1 (GND), IC2.1 (GND), IC3.1 (GND), IC4.1 (GND), IC5.10 (GND), J1.1, J3.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R8.1, R9.1, R14.1, R15.1, R16.1, R17.1, R22.1, R23.1, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2
IN1: D3.2 (A), IC5.18 (1Y1), R12.1
IN1*: IC5.2 (1A1), J3.13, R27.1
IN1_2: D5.2 (A), IC5.14 (1Y3), R19.1
IN1_2*: IC5.6 (1A3), J3.15, R4.1
IN2: D4.2 (A), IC5.16 (1Y2), R13.2
IN2*: IC5.4 (1A2), J3.14, R25.1
IN2_2: D6.2 (A), IC5.12 (1Y4), R21.2
IN2_2*: IC5.8 (1A4), J3.16, R2.1
INH1: IC5.17 (2A4), R10.1
INH1*: IC5.3 (2Y4), J3.6, R26.1
INH1_2: IC5.13 (2A2), R18.1
INH1_2*: IC5.7 (2Y2), J3.10, R3.1
INH2: IC5.15 (2A3), R11.2
INH2*: IC5.5 (2Y3), J3.8, R24.1
INH2_2: IC5.11 (2A1), R20.2
INH2_2*: IC5.9 (2Y1), J3.12, R1.1
IS1: C11.1, IC1.6 (IS), J3.5, R14.2
IS1_2: C13.1, IC3.6 (IS), J3.9, R16.2
IS2: C12.1, IC2.6 (IS), J3.7, R15.2
IS2_2: C22.1, IC4.6 (IS), J3.11, R23.2
M+1: C5.2, C7.1, IC1.8 (OUT_2), J2.1
M+2: C16.2, C17.1, IC3.8 (OUT_2), J4.1
M-1: C6.2, C8.1, IC2.8 (OUT_2), J2.2
M-2: C18.2, C19.1, IC4.8 (OUT_2), J4.2
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R30.1
unnamed: D4.1 (K), R31.1
unnamed: D5.1 (K), R32.1
unnamed: D6.1 (K), R33.1
unnamed: IC1.2 (IN), R12.2
unnamed: IC1.3 (INH), R10.2
unnamed: C9.1, IC1.5 (SR), R8.2
unnamed: IC2.2 (IN), R13.1
unnamed: IC2.3 (INH), R11.1
unnamed: C10.1, IC2.5 (SR), R9.2
unnamed: IC3.2 (IN), R19.2
unnamed: IC3.3 (INH), R18.2
unnamed: C14.1, IC3.5 (SR), R17.2
unnamed: IC4.2 (IN), R21.1
unnamed: IC4.3 (INH), R20.1
unnamed: C21.1, IC4.5 (SR), R22.2

Notes on the sheet:
Hブリッジ回路
このモタドラは2つのモーターを動かすことができる

Board: 2 copper layers, 99.1 x 99.1 mm, 73 parts (0 on the bottom side), 47 nets.
